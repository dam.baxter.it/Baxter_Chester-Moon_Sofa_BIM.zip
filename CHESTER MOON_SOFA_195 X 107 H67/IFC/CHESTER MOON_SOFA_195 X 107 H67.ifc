Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 28d9ad56-49bf-4d57-aa7d-42a8af31cb35, VersionGUID: c8d04d20-e2d5-4ef5-bfc6-a10e7f7aad19, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: CHESTER MOON_SOFA_195 X 107 H67.ifc
Time: 2026-02-23T16:27:40+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.40.26 (ITA) - IFC 24.3.40.26

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 999999; RefLongitude: 12, 35, 59, 999999; RefElevation: 0 m

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Livello:Livello (2)
Name | LongName | Elevation (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurnishingElement: CHESTER MOON_SOFA_195 X 107 H67:Chester Moon, CHESTER MOON_SOFA_195 X 107 H67:Chester Moon:145216
In: 0 - Piano Terra
Type - Material: Hand Brushed Burnished Metal, <Unnamed>, Linen
Type - Pset_ManufacturerTypeInformation - Manufacturer: Baxter S.r.l.
Material: Linen, Hand Brushed Burnished Metal
Pset_QuantityTakeOff - Reference: Chester Moon
